# Keil uVision project stm32g431_injeted_adc_test.uvprojx, settings and files
target stm32g431_injeted_adc_test (ARM-ADS)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.1.3
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: stm32g431_injeted_adc_test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32G431xx,USE_FULL_LL_DRIVER,USE_HAL_DRIVER
  c include: ../Inc;                                  ../Drivers/STM32G4xx_HAL_Driver/Inc;                                  ../Drivers/CMSIS/Device/ST/STM32G4xx/Include;                                  ../Drivers/CMSIS/Include;                  ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User
    ../Src/: main.c gpio.c adc.c dac.c dma.c tim.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_ll_gpio.c stm32g4xx_ll_adc.c stm32g4xx_ll_dma.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_ll_dac.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_ll_pwr.c stm32g4xx_ll_tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
software components: CMSIS:CORE 4.3.0
